# Keil uVision project LED blinking.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: LED blinking
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group user
    ./user/: main.c
software components: Board Support:Board Setup 0.4, Device:Startup 0.4, Drivers:CLKCTRL 0.4, Drivers:PORT 0.4
