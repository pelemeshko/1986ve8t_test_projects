# Keil uVision project 1986ve8_proj.uvproj, settings and files
target Target (IntRAM) (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _INT_RAM_
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group Source Group 1
    ./Sources/: sysinit.c main.c eerom.c wdt.c uarts.c adc.c timer.c test.c
  group 1986ve8_lib
    ./Sources/1986ve8_lib/: core_cm4.c startup_MDR1986VE8T.s
target Target (ExtMEM Dbg) (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Target (ExtMEM Rls) (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _EXT_MEM_RLS_
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
